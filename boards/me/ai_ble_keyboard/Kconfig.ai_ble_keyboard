## boards/me/ai_ble_keyboard/Kconfig.ai_ble_keyboard
```kconfig
# SPDX-License-Identifier: Apache-2.0

config BOARD_AI_BLE_KEYBOARD
	select SOC_NRF52840_QIAA
```
